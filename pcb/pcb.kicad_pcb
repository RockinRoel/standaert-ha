# Repository RockinRoel/standaert-ha

File README.md:

# Standaert Home Automation
Home automation system used at my parents' house.

This project is subdivided into three parts:

| component    | status | description |
| ------------ | ------ | ----------- |
| `pcb`        | In use (since 2019) | The KiCAD schematics and PCB layout used for the hardware |
| `controller` | In use (since 2019) | Software for the controller that is placed on the PCB. This software is written in C++ and uses PlatformIO to target the Arduin Nano. |
| `gateway`    | WIP    | Software that bridges the serial interface of the controller and home automation system software like Home Assistant. The gateway is written in Rust. |

## KiCad design pcb/pcb.kicad_pcb

File pcb/README.md:

# Standaert Home Automation PCB

This repository contains the KiCAD schematic and PCB design for
the custom board used in the home automation system at my
parents' house.

## History

Since 1995 we've used a custom home automation system that my
dad made, using:

- 4 Velleman K8000 boards for I/O (32 inputs, 32 outputs)
- a Velleman K8001 control module
- 2 Velleman K6714-16 relay boards (32 relays)
- Some dimmers, infrared remote control,...
  that are no longer in use

All light switches in the house are momentary switches wired in
parallel (one wire per switch)[^1], hence the many inputs. Every
light or group of lights is controlled by a relay.

When this system failed we went through a few iterations
of protoboards with programming done using a FEZ Cobra and the
.NET Micro Framework. We used that for a while, but it was not
entirely reliable yet.

This PCB replaces the K8000 boards and the K8001 control
module with a single board with an Arduino Nano. The only part
still in place from the old system are the relay boards.

[^1]: Mostly, sometimes multiple switches with the same
function use the same wire.

## Specifications

- 4 layer PCB
- Dimensions:
  - Width: 170mm
  - Height: 137mm
- 4 M3 mounting holes:
  - Center is 5mm from the edge
  - Horizontal spacing: 160mm
  - Vertical spacing: 127mm
- 32 outputs (J11-J14) with indicator LEDs (D33-D64)
- 32 inputs (J7-J10):
  - separate power supply, several voltages work, we use 12V
  - optically isolated (8 x LTV-847, U3-U6, U8-U11)
  - with pull-up resistors (R1-R32)
  - reverse current protection diodes (D1-D32)
- 4 MCP23017 I/O expanders (U2, U7, U12, U13)
  - Addresses are 0x20 to 0x23 when MSB is 0,
    0x24 to 0x27 when MSB is 1
- TTL serial connection (J6)
  - optically isolated (CPC5001G, U1)
  - pin-compatible with many USB adapters, e.g.
    [SparkFun Serial Basic Breakout](https://www.sparkfun.com/products/14050)
- Arduino Nano controller (A1)
  - 7V-12V input voltage, we use 9V
  - Provides 5V to the top part of the board
  - MODE switch (SW1):
    - Set to 0: serial only mode: the microcontroller just sends
      events through the serial connection, and executes
      commands received through the serial connection.
    - Set to 1: program mode: the microcontroller also executes
      its built-in program. This allows it to operate standalone
      without a serial connection.
  - Note: do not use the USB connection to connect with the
    Arduino Nano when it is mounted on the board. Instead use
    the UART connection. To program the Arduino the reset button
    can be used.
- Extension possibilities:
  - Optional I2C header (J15)
  - Optional switch to determine MSB of IO expander address
    (SW2). We only use one board, so we connect MSB to 0.

## Links

- [Bill of Materials](bom.md)
- Source code:
  - [Controller](https://gitlab.com/RockinRoel/standaert-ha-controller): runs on the Arduino Nano.
    Has the ability to function standalone 
  - [Bridge](https://gitlab.com/RockinRoel/standaert-ha-bridge) (TypeScript code that bridges the serial connection of the Arduino Nano with Home Assistant compatible MQTT)
  - [Home Assistant addon repository](https://gitlab.com/RockinRoel/standaert-ha-home-assistant-addons)

## Known issues and possible future improvements

- The board uses through-hole components only. This is because
  that's what I was most familiar and most comfortable with,
  and I erred on the side of caution since this system needs
  to operate 24/7 in a real home. This greatly increases the
  footprint of the board and limits the selection of
  components, though, driving costs up.
- Header J5 (marked "Pi" on the silkscreen) was intended so
  a ribbon cable can be connected to a Raspberry Pi. The pin-out
  corresponds to pins 1-10 on a Raspberry Pi. We ordered a
  ribbon cable for this, but the plastic on the connector
  makes it so it doesn't fit on the Raspberry Pi. You would
  have to custom make a ribbon cable with 10 wires, a 40-pin
  and a 10-pin connector to make it work. We ended up just
  using J6 with a [SparkFun Serial Basic Breakout](https://www.sparkfun.com/products/14050) instead. If I am ever to
  make another revision I might just put a USB connnector and a USB-to-serial chip on the board itself.
- It may be nice to repeat the I²C header (J15) on the left so
  that two boards can be placed side by side. If there's ever
  another revision, I may just remove J5, move J6 down (or add
  a USB connector instead) and put another I²C header on the
  left. 32 inputs and 32 outputs is plenty for our use case,
  though.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Barrel_Jack; BarrelJack_CUI_PJ-102AH_Horizontal
J3, J4: Screw_Terminal_01x02; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
J5: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J6: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Horizontal
J15: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
R65, R66: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R67, R68: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2: SW_SPDT; Switch_Slide_11.6x4mm_EG1218
U1: CPC5001G; DIP-8_W7.62mm

Connections:
+5V: A1.27 (+5V), C2.1, J3.1, J15.1, R66.1, R67.1, R68.1, SW1.1 (A), SW2.1 (A), U1.8 (VDDB); also elsewhere on the board
+9V: A1.30 (VIN), J1.1
+12V: J2.1, J4.1; also elsewhere on the board
/GNDcomm: C1.1, J5.6, J5.9, J6.1, U1.2 (GNDA)
/INTA1: A1.5 (D2); also elsewhere on the board
/INTA2: A1.6 (D3); also elsewhere on the board
/INTB1: A1.7 (D4); also elsewhere on the board
/INTB2: A1.8 (D5); also elsewhere on the board
/MSB: A1.14 (D11), SW2.2 (B); also elsewhere on the board
/PRG_MODE: A1.13 (D10), SW1.2 (B)
/RX: A1.2 (D0/RX), R66.2, U1.7 (OUT1)
/RXout: J5.8, J6.4, U1.1 (IN1)
/TX: A1.1 (D1/TX), U1.5 (IN2)
/TXout: J5.10, J6.5, R65.2, U1.3 (OUT2)
/Vcomm: C1.2, J5.1, J6.3, R65.1, U1.4 (VDDA)
/~RESET_IN1: A1.9 (D6); also elsewhere on the board
/~RESET_IN2: A1.11 (D8); also elsewhere on the board
/~RESET_OUT1: A1.12 (D9); also elsewhere on the board
/~RESET_OUT2: A1.10 (D7); also elsewhere on the board
GND: A1.4 (GND), A1.29 (GND), C2.2, J1.2, J1.3, J3.2, J15.4, SW1.3 (C), SW2.3 (C), U1.6 (GNDB); also elsewhere on the board
GNDD: J2.2, J2.3, J4.2
SCL: A1.24 (A5), J15.3, R68.2; also elsewhere on the board
SDA: A1.23 (A4), J15.2, R67.2; also elsewhere on the board

Notes on the sheet:
Power
0x20/0x24
0x21/0x25
Mounting holes
Arduino
Serial communication
0x22/0x26
0x23/0x27

Parts:
C3: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
J9, J10: Screw_Terminal_01x08; TerminalBlock_TE_282834-8_1x08_P2.54mm_Horizontal
U2: MCP23017-E_SP; DIP-28_W7.62mm; MPN MCP23017-E/SP; Digi-Key_PN MCP23017-E/SP-ND

Connections:
+5V: C3.1, U2.9 (VDD); also elsewhere on the board
/INTA1: U2.20 (INTA); also elsewhere on the board
/INTB1: U2.19 (INTB); also elsewhere on the board
/Input 1/IN0: U2.21 (GPA0); also elsewhere on the board
/Input 1/IN1: U2.22 (GPA1); also elsewhere on the board
/Input 1/IN2: U2.23 (GPA2); also elsewhere on the board
/Input 1/IN3: U2.24 (GPA3); also elsewhere on the board
/Input 1/IN4: U2.25 (GPA4); also elsewhere on the board
/Input 1/IN5: U2.26 (GPA5); also elsewhere on the board
/Input 1/IN6: U2.27 (GPA6); also elsewhere on the board
/Input 1/IN7: U2.28 (GPA7); also elsewhere on the board
/Input 1/IN8: U2.1 (GPB0); also elsewhere on the board
/Input 1/IN9: U2.2 (GPB1); also elsewhere on the board
/Input 1/IN10: U2.3 (GPB2); also elsewhere on the board
/Input 1/IN11: U2.4 (GPB3); also elsewhere on the board
/Input 1/IN12: U2.5 (GPB4); also elsewhere on the board
/Input 1/IN13: U2.6 (GPB5); also elsewhere on the board
/Input 1/IN14: U2.7 (GPB6); also elsewhere on the board
/Input 1/IN15: U2.8 (GPB7); also elsewhere on the board
/Input 2/Pin0: J9.1; also elsewhere on the board
/Input 2/Pin1: J9.2; also elsewhere on the board
/Input 2/Pin2: J9.3; also elsewhere on the board
/Input 2/Pin3: J9.4; also elsewhere on the board
/Input 2/Pin4: J9.5; also elsewhere on the board
/Input 2/Pin5: J9.6; also elsewhere on the board
/Input 2/Pin6: J9.7; also elsewhere on the board
/Input 2/Pin7: J9.8; also elsewhere on the board
/Input 2/Pin8: J10.1; also elsewhere on the board
/Input 2/Pin9: J10.2; also elsewhere on the board
/Input 2/Pin10: J10.3; also elsewhere on the board
/Input 2/Pin11: J10.4; also elsewhere on the board
/Input 2/Pin12: J10.5; also elsewhere on the board
/Input 2/Pin13: J10.6; also elsewhere on the board
/Input 2/Pin14: J10.7; also elsewhere on the board
/Input 2/Pin15: J10.8; also elsewhere on the board
/MSB: U2.17 (A2); also elsewhere on the board
/~RESET_IN1: U2.18 (~RESET); also elsewhere on the board
GND: C3.2, U2.10 (VSS), U2.15 (A0), U2.16 (A1); also elsewhere on the board
SCL: U2.12 (SCK); also elsewhere on the board
SDA: U2.13 (SDA); also elsewhere on the board

Parts of its further copies:
C4: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
J7, J8: Screw_Terminal_01x08; TerminalBlock_TE_282834-8_1x08_P2.54mm_Horizontal
U7: MCP23017-E_SP; DIP-28_W7.62mm; MPN MCP23017-E/SP; Digi-Key_PN MCP23017-E/SP-ND

Connections of its further copies:
+5V: C4.1, U7.9 (VDD), U7.15 (A0); also elsewhere on the board
/INTA2: U7.20 (INTA); also elsewhere on the board
/INTB2: U7.19 (INTB); also elsewhere on the board
/Input 1/Pin4: J7.5; also elsewhere on the board
/Input 1/Pin5: J7.6; also elsewhere on the board
/Input 1/Pin6: J7.7; also elsewhere on the board
/Input 1/Pin7: J7.8; also elsewhere on the board
/Input 1/Pin8: J8.1; also elsewhere on the board
/Input 1/Pin9: J8.2; also elsewhere on the board
/Input 1/Pin10: J8.3; also elsewhere on the board
/Input 1/Pin11: J8.4; also elsewhere on the board
/Input 1/Pin12: J8.5; also elsewhere on the board
/Input 1/Pin13: J8.6; also elsewhere on the board
/Input 1/Pin14: J8.7; also elsewhere on the board
/Input 1/Pin15: J8.8; also elsewhere on the board
/Input 2/IN0: U7.21 (GPA0); also elsewhere on the board
/Input 2/IN1: U7.22 (GPA1); also elsewhere on the board
/Input 2/IN2: U7.23 (GPA2); also elsewhere on the board
/Input 2/IN3: U7.24 (GPA3); also elsewhere on the board
/Input 2/IN4: U7.25 (GPA4); also elsewhere on the board
/Input 2/IN5: U7.26 (GPA5); also elsewhere on the board
/Input 2/IN6: U7.27 (GPA6); also elsewhere on the board
/Input 2/IN7: U7.28 (GPA7); also elsewhere on the board
/Input 2/IN8: U7.1 (GPB0); also elsewhere on the board
/Input 2/IN9: U7.2 (GPB1); also elsewhere on the board
/Input 2/IN10: U7.3 (GPB2); also elsewhere on the board
/Input 2/IN11: U7.4 (GPB3); also elsewhere on the board
/Input 2/IN12: U7.5 (GPB4); also elsewhere on the board
/Input 2/IN13: U7.6 (GPB5); also elsewhere on the board
/Input 2/IN14: U7.7 (GPB6); also elsewhere on the board
/Input 2/IN15: U7.8 (GPB7); also elsewhere on the board
/MSB: U7.17 (A2); also elsewhere on the board
/~RESET_IN2: U7.18 (~RESET); also elsewhere on the board
GND: C4.2, U7.10 (VSS), U7.16 (A1); also elsewhere on the board
SCL: U7.12 (SCK); also elsewhere on the board
SDA: U7.13 (SDA); also elsewhere on the board

Parts:
C5: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
J11, J12: Conn_01x08_Male; TerminalBlock_TE_282834-8_1x08_P2.54mm_Horizontal
U12: MCP23017-E_SP; DIP-28_W7.62mm; MPN MCP23017-E/SP; Digi-Key_PN MCP23017-E/SP-ND

Connections:
+5V: C5.1, U12.9 (VDD), U12.16 (A1); also elsewhere on the board
/MSB: U12.17 (A2); also elsewhere on the board
/Output 1/Out0: J11.1, U12.21 (GPA0); also elsewhere on the board
/Output 1/Out1: J11.2, U12.22 (GPA1); also elsewhere on the board
/Output 1/Out2: J11.3, U12.23 (GPA2); also elsewhere on the board
/Output 1/Out3: J11.4, U12.24 (GPA3); also elsewhere on the board
/Output 1/Out4: J11.5, U12.25 (GPA4); also elsewhere on the board
/Output 1/Out5: J11.6, U12.26 (GPA5); also elsewhere on the board
/Output 1/Out6: J11.7, U12.27 (GPA6); also elsewhere on the board
/Output 1/Out7: J11.8, U12.28 (GPA7); also elsewhere on the board
/Output 1/Out8: J12.1, U12.1 (GPB0); also elsewhere on the board
/Output 1/Out9: J12.2, U12.2 (GPB1); also elsewhere on the board
/Output 1/Out10: J12.3, U12.3 (GPB2); also elsewhere on the board
/Output 1/Out11: J12.4, U12.4 (GPB3); also elsewhere on the board
/Output 1/Out12: J12.5, U12.5 (GPB4); also elsewhere on the board
/Output 1/Out13: J12.6, U12.6 (GPB5); also elsewhere on the board
/Output 1/Out14: J12.7, U12.7 (GPB6); also elsewhere on the board
/Output 1/Out15: J12.8, U12.8 (GPB7); also elsewhere on the board
/~RESET_OUT1: U12.18 (~RESET); also elsewhere on the board
GND: C5.2, U12.10 (VSS), U12.15 (A0); also elsewhere on the board
SCL: U12.12 (SCK); also elsewhere on the board
SDA: U12.13 (SDA); also elsewhere on the board

Parts of its further copies:
C6: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
J13, J14: Conn_01x08_Male; TerminalBlock_TE_282834-8_1x08_P2.54mm_Horizontal
U13: MCP23017-E_SP; DIP-28_W7.62mm; MPN MCP23017-E/SP; Digi-Key_PN MCP23017-E/SP-ND

Connections of its further copies:
+5V: C6.1, U13.9 (VDD), U13.15 (A0), U13.16 (A1); also elsewhere on the board
/MSB: U13.17 (A2); also elsewhere on the board
/Output 2/Out0: J13.1, U13.21 (GPA0); also elsewhere on the board
/Output 2/Out1: J13.2, U13.22 (GPA1); also elsewhere on the board
/Output 2/Out2: J13.3, U13.23 (GPA2); also elsewhere on the board
/Output 2/Out3: J13.4, U13.24 (GPA3); also elsewhere on the board
/Output 2/Out4: J13.5, U13.25 (GPA4); also elsewhere on the board
/Output 2/Out5: J13.6, U13.26 (GPA5); also elsewhere on the board
/Output 2/Out6: J13.7, U13.27 (GPA6); also elsewhere on the board
/Output 2/Out7: J13.8, U13.28 (GPA7); also elsewhere on the board
/Output 2/Out8: J14.1, U13.1 (GPB0); also elsewhere on the board
/Output 2/Out9: J14.2, U13.2 (GPB1); also elsewhere on the board
/Output 2/Out10: J14.3, U13.3 (GPB2); also elsewhere on the board
/Output 2/Out11: J14.4, U13.4 (GPB3); also elsewhere on the board
/Output 2/Out12: J14.5, U13.5 (GPB4); also elsewhere on the board
/Output 2/Out13: J14.6, U13.6 (GPB5); also elsewhere on the board
/Output 2/Out14: J14.7, U13.7 (GPB6); also elsewhere on the board
/Output 2/Out15: J14.8, U13.8 (GPB7); also elsewhere on the board
/~RESET_OUT2: U13.18 (~RESET); also elsewhere on the board
GND: C6.2, U13.10 (VSS); also elsewhere on the board
SCL: U13.12 (SCK); also elsewhere on the board
SDA: U13.13 (SDA); also elsewhere on the board

Parts:
D1, D2, D3, D4: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
R1, R2, R3, R4: 1k 1W; R_Axial_DIN0414_L11.9mm_D4.5mm_P5.08mm_Vertical
U3: LTV-847; DIP-16_W7.62mm; MPN LTV-847; Digi-Key_PN 160-1370-5-ND

Connections:
+12V: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U3.1, U3.3, U3.5, U3.7; also elsewhere on the board
/Input 1/IN0: U3.16; also elsewhere on the board
/Input 1/IN1: U3.14; also elsewhere on the board
/Input 1/IN2: U3.12; also elsewhere on the board
/Input 1/IN3: U3.10; also elsewhere on the board
GND: U3.9, U3.11, U3.13, U3.15; also elsewhere on the board

Parts of its further copies:
D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 1k 1W; R_Axial_DIN0414_L11.9mm_D4.5mm_P5.08mm_Vertical
U4, U5, U6, U8, U9, U10, U11: LTV-847; DIP-16_W7.62mm; MPN LTV-847; Digi-Key_PN 160-1370-5-ND

Connections of its further copies:
+12V: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), U4.1, U4.3, U4.5, U4.7, U5.1, U5.3, U5.5, U5.7, U6.1, U6.3, U6.5, U6.7, U8.1, U8.3, U8.5, U8.7, U9.1, U9.3, U9.5, U9.7, U10.1, U10.3, U10.5, U10.7, U11.1, U11.3, U11.5, U11.7; also elsewhere on the board
/Input 1/IN4: U4.16; also elsewhere on the board
/Input 1/IN5: U4.14; also elsewhere on the board
/Input 1/IN6: U4.12; also elsewhere on the board
/Input 1/IN7: U4.10; also elsewhere on the board
/Input 1/IN8: U5.16; also elsewhere on the board
/Input 1/IN9: U5.14; also elsewhere on the board
/Input 1/IN10: U5.12; also elsewhere on the board
/Input 1/IN11: U5.10; also elsewhere on the board
/Input 1/IN12: U6.16; also elsewhere on the board
/Input 1/IN13: U6.14; also elsewhere on the board
/Input 1/IN14: U6.12; also elsewhere on the board
/Input 1/IN15: U6.10; also elsewhere on the board
/Input 1/Pin4: R5.1; also elsewhere on the board
/Input 1/Pin5: R6.1; also elsewhere on the board
/Input 1/Pin6: R7.1; also elsewhere on the board
/Input 1/Pin7: R8.1; also elsewhere on the board
/Input 1/Pin8: R9.1; also elsewhere on the board
/Input 1/Pin9: R10.1; also elsewhere on the board
/Input 1/Pin10: R11.1; also elsewhere on the board
/Input 1/Pin11: R12.1; also elsewhere on the board
/Input 1/Pin12: R13.1; also elsewhere on the board
/Input 1/Pin13: R14.1; also elsewhere on the board
/Input 1/Pin14: R15.1; also elsewhere on the board
/Input 1/Pin15: R16.1; also elsewhere on the board
/Input 2/IN0: U8.16; also elsewhere on the board
/Input 2/IN1: U8.14; also elsewhere on the board
/Input 2/IN2: U8.12; also elsewhere on the board
/Input 2/IN3: U8.10; also elsewhere on the board
/Input 2/IN4: U9.16; also elsewhere on the board
/Input 2/IN5: U9.14; also elsewhere on the board
/Input 2/IN6: U9.12; also elsewhere on the board
/Input 2/IN7: U9.10; also elsewhere on the board
/Input 2/IN8: U10.16; also elsewhere on the board
/Input 2/IN9: U10.14; also elsewhere on the board
/Input 2/IN10: U10.12; also elsewhere on the board
/Input 2/IN11: U10.10; also elsewhere on the board
/Input 2/IN12: U11.16; also elsewhere on the board
/Input 2/IN13: U11.14; also elsewhere on the board
/Input 2/IN14: U11.12; also elsewhere on the board
/Input 2/IN15: U11.10; also elsewhere on the board
/Input 2/Pin0: R17.1; also elsewhere on the board
/Input 2/Pin1: R18.1; also elsewhere on the board
/Input 2/Pin2: R19.1; also elsewhere on the board
/Input 2/Pin3: R20.1; also elsewhere on the board
/Input 2/Pin4: R21.1; also elsewhere on the board
/Input 2/Pin5: R22.1; also elsewhere on the board
/Input 2/Pin6: R23.1; also elsewhere on the board
/Input 2/Pin7: R24.1; also elsewhere on the board
/Input 2/Pin8: R25.1; also elsewhere on the board
/Input 2/Pin9: R26.1; also elsewhere on the board
/Input 2/Pin10: R27.1; also elsewhere on the board
/Input 2/Pin11: R28.1; also elsewhere on the board
/Input 2/Pin12: R29.1; also elsewhere on the board
/Input 2/Pin13: R30.1; also elsewhere on the board
/Input 2/Pin14: R31.1; also elsewhere on the board
/Input 2/Pin15: R32.1; also elsewhere on the board
GND: U4.9, U4.11, U4.13, U4.15, U5.9, U5.11, U5.13, U5.15, U6.9, U6.11, U6.13, U6.15, U8.9, U8.11, U8.13, U8.15, U9.9, U9.11, U9.13, U9.15, U10.9, U10.11, U10.13, U10.15, U11.9, U11.11, U11.13, U11.15; also elsewhere on the board
unnamed: D5.2 (A), R5.2, U4.2
unnamed: D6.2 (A), R6.2, U4.4
unnamed: D7.2 (A), R7.2, U4.6
unnamed: D8.2 (A), R8.2, U4.8
unnamed: D9.2 (A), R9.2, U5.2
unnamed: D10.2 (A), R10.2, U5.4
unnamed: D11.2 (A), R11.2, U5.6
unnamed: D12.2 (A), R12.2, U5.8
unnamed: D13.2 (A), R13.2, U6.2
unnamed: D14.2 (A), R14.2, U6.4
unnamed: D15.2 (A), R15.2, U6.6
unnamed: D16.2 (A), R16.2, U6.8
unnamed: D17.2 (A), R17.2, U8.2
unnamed: D18.2 (A), R18.2, U8.4
unnamed: D19.2 (A), R19.2, U8.6
unnamed: D20.2 (A), R20.2, U8.8
unnamed: D21.2 (A), R21.2, U9.2
unnamed: D22.2 (A), R22.2, U9.4
unnamed: D23.2 (A), R23.2, U9.6
unnamed: D24.2 (A), R24.2, U9.8
unnamed: D25.2 (A), R25.2, U10.2
unnamed: D26.2 (A), R26.2, U10.4
unnamed: D27.2 (A), R27.2, U10.6
unnamed: D28.2 (A), R28.2, U10.8
unnamed: D29.2 (A), R29.2, U11.2
unnamed: D30.2 (A), R30.2, U11.4
unnamed: D31.2 (A), R31.2, U11.6
unnamed: D32.2 (A), R32.2, U11.8

Parts:
D33: RED; LED_D3.0mm
R33: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
/Output 1/Out0: D33.2 (A); also elsewhere on the board
GND: R33.1; also elsewhere on the board
unnamed: D33.1 (K), R33.2

Parts of its further copies:
D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: RED; LED_D3.0mm
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections of its further copies:
/Output 1/Out1: D34.2 (A); also elsewhere on the board
/Output 1/Out2: D35.2 (A); also elsewhere on the board
/Output 1/Out3: D36.2 (A); also elsewhere on the board
/Output 1/Out4: D37.2 (A); also elsewhere on the board
/Output 1/Out5: D38.2 (A); also elsewhere on the board
/Output 1/Out6: D39.2 (A); also elsewhere on the board
/Output 1/Out7: D40.2 (A); also elsewhere on the board
/Output 1/Out8: D41.2 (A); also elsewhere on the board
/Output 1/Out9: D42.2 (A); also elsewhere on the board
/Output 1/Out10: D43.2 (A); also elsewhere on the board
/Output 1/Out11: D44.2 (A); also elsewhere on the board
/Output 1/Out12: D45.2 (A); also elsewhere on the board
/Output 1/Out13: D46.2 (A); also elsewhere on the board
/Output 1/Out14: D47.2 (A); also elsewhere on the board
/Output 1/Out15: D48.2 (A); also elsewhere on the board
/Output 2/Out0: D49.2 (A); also elsewhere on the board
/Output 2/Out1: D50.2 (A); also elsewhere on the board
/Output 2/Out2: D51.2 (A); also elsewhere on the board
/Output 2/Out3: D52.2 (A); also elsewhere on the board
/Output 2/Out4: D53.2 (A); also elsewhere on the board
/Output 2/Out5: D54.2 (A); also elsewhere on the board
/Output 2/Out6: D55.2 (A); also elsewhere on the board
/Output 2/Out7: D56.2 (A); also elsewhere on the board
/Output 2/Out8: D57.2 (A); also elsewhere on the board
/Output 2/Out9: D58.2 (A); also elsewhere on the board
/Output 2/Out10: D59.2 (A); also elsewhere on the board
/Output 2/Out11: D60.2 (A); also elsewhere on the board
/Output 2/Out12: D61.2 (A); also elsewhere on the board
/Output 2/Out13: D62.2 (A); also elsewhere on the board
/Output 2/Out14: D63.2 (A); also elsewhere on the board
/Output 2/Out15: D64.2 (A); also elsewhere on the board
GND: R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R56.1, R57.1, R58.1, R59.1, R60.1, R61.1, R62.1, R63.1, R64.1; also elsewhere on the board
unnamed: D34.1 (K), R34.2
unnamed: D35.1 (K), R35.2
unnamed: D36.1 (K), R36.2
unnamed: D37.1 (K), R37.2
unnamed: D38.1 (K), R38.2
unnamed: D39.1 (K), R39.2
unnamed: D40.1 (K), R40.2
unnamed: D41.1 (K), R41.2
unnamed: D42.1 (K), R42.2
unnamed: D43.1 (K), R43.2
unnamed: D44.1 (K), R44.2
unnamed: D45.1 (K), R45.2
unnamed: D46.1 (K), R46.2
unnamed: D47.1 (K), R47.2
unnamed: D48.1 (K), R48.2
unnamed: D49.1 (K), R49.2
unnamed: D50.1 (K), R50.2
unnamed: D51.1 (K), R51.2
unnamed: D52.1 (K), R52.2
unnamed: D53.1 (K), R53.2
unnamed: D54.1 (K), R54.2
unnamed: D55.1 (K), R55.2
unnamed: D56.1 (K), R56.2
unnamed: D57.1 (K), R57.2
unnamed: D58.1 (K), R58.2
unnamed: D59.1 (K), R59.2
unnamed: D60.1 (K), R60.2
unnamed: D61.1 (K), R61.2
unnamed: D62.1 (K), R62.2
unnamed: D63.1 (K), R63.2
unnamed: D64.1 (K), R64.2

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
Board: 4 copper layers, 170.2 x 137.2 mm, 173 parts (0 on the bottom side), 183 nets.
